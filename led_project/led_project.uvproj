# Keil uVision project led_project.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: led_project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\drivers\gpio\inc;..\drivers\rcc\inc;..\services\led\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Source
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c main.c
  group Doc
    ./: Abstract.txt
  group Drivers
    ../drivers/gpio/inc/: gpio.h
    ../drivers/gpio/src/: gpio.c
    ../drivers/rcc/inc/: rcc.h
    ../drivers/rcc/src/: rcc.c
  group Services
    ../services/led/inc/: led.h
    ../services/led/src/: led.c
